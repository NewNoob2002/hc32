# Keil uVision project lvgl.uvprojx, settings and files
target LVGL (6220000::V6.22::ARMCLANG)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F46x.1.0.2
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lvgl +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c misc: -Wno-unused-value
  c include: ..\app;..\cmsis\Include;..\cmsis\bsp\ev_hc32f460_lqfp100_v2;..\cmsis\Device\HDSC\hc32f4xx\Include;..\driver\inc;..\driver\lvgl
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  group app
    ../app/: main.c lvgl_test.c LCD.c
  group cmsis
    ../cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
    ../cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f460.s
  group driver
    ../driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mpu.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c hc32_ll_utility.c
  group ev_hc32f460_lqfp100_v2
    ../cmsis/bsp/ev_hc32f460_lqfp100_v2/: ev_hc32f460_lqfp100_v2.c
  group lvgl_core
    ../driver/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl_draw
    ../driver/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../driver/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl_extra
    ../driver/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../driver/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../driver/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../driver/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../driver/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../driver/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../driver/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../driver/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../driver/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../driver/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../driver/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../driver/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../driver/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../driver/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../driver/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../driver/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../driver/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../driver/lvgl/src/extra/others/msg/: lv_msg.c
    ../driver/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../driver/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../driver/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../driver/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../driver/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../driver/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../driver/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../driver/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../driver/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../driver/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../driver/lvgl/src/extra/widgets/led/: lv_led.c
    ../driver/lvgl/src/extra/widgets/list/: lv_list.c
    ../driver/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../driver/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../driver/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../driver/lvgl/src/extra/widgets/span/: lv_span.c
    ../driver/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../driver/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../driver/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../driver/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../driver/lvgl/src/extra/widgets/win/: lv_win.c
    ../driver/lvgl/src/extra/: lv_extra.c
  group lvgl_font
    ../driver/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl_hal
    ../driver/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl_misc
    ../driver/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl_widgets
    ../driver/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl_porting
    ../driver/lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group lvgl
    ../driver/lvgl/: lv_conf.h lvgl.h
